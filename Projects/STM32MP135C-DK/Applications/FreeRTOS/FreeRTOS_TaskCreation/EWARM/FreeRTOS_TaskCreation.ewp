# IAR project FreeRTOS_TaskCreation.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32MP135F ST STM32MP135F
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 54
  General.FPU2: 5
  ICCARM.CCDefines: STM32MP135Fxx; CORE_CA7; USE_STM32MP13XX_DK; USE_HAL_DRIVER; FreeRTOS; USE_DDR; MMU_USE; CACHE_USE; MCP_IOEXPANDER
  ICCARM.CCIncludePath2: ../../Core/Inc; ../../../../../../../Middlewares/Third_Party/FreeRTOS/Source/include; ../../../../../../../Middlewares/Third_Party/FreeRTOS/Source/portable/GCC/ARM_CA9; ../../../../../../../Drivers/STM32MP13xx_HAL_Driver/Inc; ../../../../../../../Drivers/CMSIS/Device/ST/STM32MP13xx/Include; ../../../../../../../Drivers/CMSIS/Core_A/Include; ../../../../../../../Drivers/BSP/STM32MP13xx_DISCO; ../../../../../../../Drivers/BSP/Components/Common
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.AUserIncludes: ..\Core\Inc; ..\..\..\..\..\..\Middlewares\Third_Party\FreeRTOS\Source\portable\IAR\ARM_CA9
  OBJCOPY.OOCOutputFile: FreeRTOS_TaskCreation.srec
  ILINK.IlinkOutputFile: FreeRTOS_TaskCreation.out
  ILINK.IlinkIcfFile: stm32mp13xx_a7_ddr.icf
  ILINK.IlinkProgramEntryLabel: Reset_Handler
configuration Release (ARM)
  as the first configuration, except:
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group Application/EWARM
    ./: startup_stm32mp135c_ca7_freertos.s
  group Application/User/Core
    ../Core/Src/: main.c stm32mp13xx_hal_msp.c stm32mp13xx_hal_timebase_tim.c stm32mp13xx_it.c
  group Doc
    ../: readme.txt
  group Drivers/BSP/Components/mcp23x17
    ../../../../../../Drivers/BSP/Components/mcp23x17/: mcp23x17.c mcp23x17_reg.c
  group Drivers/BSP/STM32MP13xx_DISCO
    ../../../../../../Drivers/BSP/STM32MP13xx_DISCO/: stm32mp13xx_disco.c stm32mp13xx_disco_bus.c stm32mp13xx_disco_io.c stm32mp13xx_disco_stpmic1.c
  group Drivers/CMSIS
    ../../../../../../Drivers/CMSIS/Core_A/Source/: irq_ctrl_gic.c
    ../../../../../../Drivers/CMSIS/Device/ST/STM32MP13xx/Source/Templates/: mmu_stm32mp13xx.c
    ../: system_stm32mp13xx_A7_freeRTOS.c
  group Drivers/STM32MP13xx_HAL_Driver
    ../../../../../../Drivers/STM32MP13xx_HAL_Driver/Src/: stm32mp13xx_hal.c stm32mp13xx_hal_dma.c stm32mp13xx_hal_dma_ex.c stm32mp13xx_hal_exti.c stm32mp13xx_hal_gpio.c stm32mp13xx_hal_i2c.c stm32mp13xx_hal_i2c_ex.c stm32mp13xx_hal_mdma.c stm32mp13xx_hal_pwr.c stm32mp13xx_hal_pwr_ex.c stm32mp13xx_hal_rcc.c stm32mp13xx_hal_rcc_ex.c stm32mp13xx_hal_tim.c stm32mp13xx_hal_tim_ex.c stm32mp13xx_hal_uart.c stm32mp13xx_hal_uart_ex.c
  group Middlewares/FreeRTOS
    ../../../../../../Middlewares/Third_Party/FreeRTOS/Source/: croutine.c event_groups.c list.c queue.c tasks.c timers.c
  group Middlewares/FreeRTOS/Portable
    ../../../../../../Middlewares/Third_Party/FreeRTOS/Source/portable/MemMang/: heap_4.c
    ../../../../../../Middlewares/Third_Party/FreeRTOS/Source/portable/IAR/ARM_CA9/: port.c portASM.s
